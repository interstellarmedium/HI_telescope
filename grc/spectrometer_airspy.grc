options:
  parameters:
    author: Jonathan Williams
    description: modified from DSPIRA
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: spectrometer for HI line using nooelec SDR
  states: {}

blocks:
- name: az
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Azimuth
    type: int
    value: '0'
  states: {}
- name: collect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: '"Smooth"'
    label0: '"Raw"'
    label1: '"Smooth"'
    num_opts: '2'
    option0: '"raw"'
    option1: '"nocal"'
    type: string
    value: '"raw"'
    widget: radio_buttons
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: datadir
  id: variable
  parameters:
    value: '"/Users/jpw/airspy_spectra/"'
  states: {}
- name: el
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Elevation
    type: int
    value: '0'
  states: {}
- name: filename
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,2,1,1
    label: Filename
    type: string
    value: '"timestamp_" + loc + "_" + str(az) + "_" + str(el) + ".csv"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1420.0e6
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: freq - samp_rate/2
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: samp_rate/vec_length
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: loc
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,1
    label: Location
    type: string
    value: '"Honolulu"'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: save_toggle_csv
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,3,1,1
    label: Write to CSV files
    label0: Write to File
    label1: Not writing to file
    num_opts: '2'
    option0: '"True"'
    option1: '"False"'
    type: string
    value: '"False"'
    widget: radio_buttons
  states: {}
- name: short_or_long
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,3,1,1
    label: Inegration Time
    label0: Short (1 sec)
    label1: Long (10 sec)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)
  states: {}
- name: t_int
  id: variable
  parameters:
    comment: Long integration time
    value: '10'
  states: {}
- name: t_spec
  id: variable
  parameters:
    comment: Spectrum update time and short option integration time
    value: '1'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: ymax
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: ymax
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1000'
    stop: '100000'
    value: '50000'
  states: {}
- name: ymin
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: ymin
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1000'
    stop: '50000'
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 2*vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*vec_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(t_spec*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '4096'
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '4096'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: strean
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=1,pack=0
    bb_gain0: '10'
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 3,3,2,1
    name: '"Heartbeat"'
    size: '1024'
    type: float
    xmax: '0.03'
    xmin: '-0.03'
  states: {}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 2,0,4,3
    name: Data stream
    showports: 'True'
    vlen: vec_length
    x_axis_label: '"Frequency"'
    x_start: freq - samp_rate/2
    x_step: samp_rate/vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    y_units: '"Power"'
    ymax: ymax
    ymin: ymin
  states: {}
- name: radio_astro_csv_filesink_0
  id: radio_astro_csv_filesink
  parameters:
    az: str(az)
    elev: str(el)
    freq: freq
    integration_select: short_or_long
    location: loc
    prefix: datadir
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: t_int
    vec_length: vec_length
  states: {}
- name: radio_astro_systemp_calibration_0
  id: radio_astro_systemp_calibration
  parameters:
    az: ''
    clip_toggle: ''
    collect: collect
    elev: ''
    freq: freq
    location: ''
    prefix: datadir
    samp_rate: samp_rate
    spectrumcapture_toggle: ''
    vec_length: vec_length
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0_0, '0', radio_astro_systemp_calibration_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0_0, '0', blocks_complex_to_real_0, '0']
- [osmosdr_source_0_0, '0', blocks_delay_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_delay_0_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_delay_0_0_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [radio_astro_systemp_calibration_0, '0', qtgui_vector_sink_f_0_0_1, '0']
- [radio_astro_systemp_calibration_0, '0', radio_astro_csv_filesink_0, '0']
- [radio_astro_systemp_calibration_0, '1', blocks_null_sink_0, '0']
- [radio_astro_systemp_calibration_0, '2', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
